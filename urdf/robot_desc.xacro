Commit message: Part 1 Complete

File: urdf/robot_desc.xacro (robot description, xacro)
@@ -18,5 +18,5 @@
         <parent link="world"/>
         <child link="base"/>
-        <origin xyz="0 0 0" rpy="0 0 -1.57"/>
+        <origin xyz="0 0 0" rpy="0 0 0"/>
     </joint>
     <!-- Base Link -->
